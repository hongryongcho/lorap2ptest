# IAR project PowerNode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: include; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; source; source\DS18B20
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PowerNode.bin
  ILINK.IlinkOutputFile: PowerNode.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\Sources\STM32lib\inc; ..\Sources\User\inc; ..\Sources\Applicationlib\inc; ..\Sources\User\inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: PowerNode.hex
  ILINK.IlinkIcfFile: C:\WORK\ARM_M3\PowerMeter\PowerMeter_V1.01\Project\ICF_FILE\stm32f10x_flash.icf
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group EWARMv5.4
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group EWARMv5.4/StmDriver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    source/LORA/: lora.c lora.h
    source/: main.c stm32f10x_it.c system_stm32f10x.c util.c
  group USER/MODBUS
    source/Modbus/: modbus.c
